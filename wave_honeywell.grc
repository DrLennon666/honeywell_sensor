<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1e3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>2</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate//2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>C:\Users\craig\OneDrive\Documents\iq\garage_tamper_SDRSharp_20230909_003155Z_344257000Hz_IQ (1).wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!

This block was stoloen from https://github.com/jordib123/ook-demodulator/blob/master/ook_demod_block.py

Honeywell 5816 specific additions are mine.
"""
import time
import numpy as np
from gnuradio import gr

class blk (gr.sync_block):
    """
    Block to decode the data on an already squared signal, comprised of 0's and 1's.
    """
    def __init__ (self 
        , symbol_rate = 600
		, sample_rate = 1e6
		, manchester_decoding = False
		, prepend_manchester = False
        , sink_file = None):
        """
        Constructor.

        Args:
            symbol_rate -&gt; Rate of symbols
            sample_rate -&gt; Number of samples per second
            manchester_decoding -&gt; Enable/disable manchester decoding
            sink_file -&gt; File to dump the packets. If it's 'None', prints them on STDOUT
        """
        gr.sync_block.__init__(
            self,
            name = 'OOK demod',
            in_sig = [np.float32],
            out_sig = []
        )
        self.manchester_decoding = manchester_decoding
        self.prepend_manchester = prepend_manchester
        self.sink_file = None
        if(sink_file != None):
            self.sink_file = open(sink_file, "a")

        # amount of samples per symbol
        self.threshold = sample_rate / symbol_rate
        # amount of samples that can be wrong when counting the 1's and 0's
        self.error_threshold = self.threshold / 4
        self.packet = ''
        self.count_1 = 0 # Counts consecutive 1's
        self.count_0 = 0 # Counts consecutive 0's
        self.sample_1_complete = False
        self.sample_0_complete = False


    def work (self, input_items, *args, **kwargs):
        samples = input_items[0]
	
        signal_detected = np.where(samples == 1)[0]
        if(len(signal_detected) &gt; 0):
            for i in range(0, len(samples) - 1):
                self.count_samples(samples[i], samples[i + 1])
                if(self.sample_1_complete):
                    self.count_1, self.sample_1_complete = self.process_sample('1', self.count_1)
                elif(self.sample_0_complete):
                    self.count_0, self.sample_0_complete = self.process_sample('0', self.count_0)
        elif(len(samples) &gt; 0 and len(self.packet) &gt; 0):
            self.packet_found()

        return len(samples)

    def packet_found(self):
        self.packet += '0' # Last 0 of packet is never detected due to the bounded 0 count (in process_sample_0), so add manually

        if(self.manchester_decoding):
            self.packet = self.manchester_decoder(self.packet)

        self.output_packet(self.packet)
        self.packet = ''

   
    def output_packet(self, output):
        if(self.sink_file):
            self.sink_file.write(output + '\n')
        else:
            print(output)


    def count_samples(self, sample1, sample2):
        if(sample1 == 1):
            self.count_1 += 1
            if(sample2 == 0):
                self.sample_1_complete = True 
        elif(sample1 == 0):
            self.count_0 += 1
            if(sample2 == 1):
                self.sample_0_complete = True 

    
    def process_sample(self, bit, count):
        if(count &gt; self.threshold - self.error_threshold and count &lt; self.threshold + self.error_threshold):
            self.packet += bit
        elif(count &gt; (self.threshold - self.error_threshold) * 2 and count &lt; (self.threshold + self.error_threshold) * 2):
            self.packet += bit + bit
        return 0, False

		
    def manchester_decoder(self, packet):
        if self.prepend_manchester:
		    packet='0'+packet # for the Honeywell 5816 a 0 must be prepended
        decode=''
        for i in range(0, len(packet) - 1, 2):
            bits = packet[i] + packet[i + 1]
            if(bits == '10'):
                decode += '0'
            elif(bits == '01'):
                decode += '1'
            else:
                i -= 1
        return decode</value></param>
<param><key>manchester_decoding</key><value>True</value></param>
<param><key>prepend_manchester</key><value>True</value></param>
<param><key>sample_rate</key><value>2.4e6</value></param>
<param><key>sink_file</key><value>None</value></param>
<param><key>symbol_rate</key><value>3675*2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>102400</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
