options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: cf
  id: variable
  parameters:
    value: 344.8e6
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: offset
  id: variable
  parameters:
    value: '-190e3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: sink_file_name
  id: variable
  parameters:
    value: None
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 3675*2
  states: {}
- name: trans_width
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: RTLSDR_OOK_Demod
  id: note
  parameters:
    note: Use this OOK block to demod over the air bursts.  In this case the SR at the block drops to 1.2e6 because we used a freq xlating filter with a decimation of 2.
  states: {}
- name: Wave_File_OOK_Demod
  id: note
  parameters:
    note: Use this OOK block to demod wave files recorded with SDR#.  In this case the SR remains 2.4e6 because we didn't use a freq xlating filter with a decimation of 2.
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1e3
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '2'
    init: '0'
    low: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\craig\OneDrive\Documents\iq\garage_tamper_SDRSharp_20230909_003155Z_344257000Hz_IQ (1).wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each this file is saved, GRC will instantiate the first class it finds to get
      ports and parameters of your block. The arguments to __init__  will be the
      parameters. All of them are required to have default values!

      This block was stolen from https://github.com/jordib123/ook-demodulator/blob/master/ook_demod_block.py

      Honeywell 5816 specific additions are mine.
      """
      import time
      import pmt
      import numpy as np
      from gnuradio import gr

      class blk (gr.sync_block):
          """
          Block to decode the data on an already squared signal, comprised of 0's and 1's.
          """
          def __init__ (self 
              , symbol_rate = 600
      		, sample_rate = 1e6
      		, manchester_decoding = False
      		, prepend_manchester = False
              , sink_file = None):
              """
              Constructor.

              Args:
                  symbol_rate -> Rate of symbols
                  sample_rate -> Number of samples per second
                  manchester_decoding -> Enable/disable manchester decoding
                  sink_file -> File to dump the packets. If it's 'None', prints them on STDOUT
              """
              gr.sync_block.__init__(
                  self,
                  name = 'OOK demod',
                  in_sig = [np.float32],
                  out_sig = []
              )
              self.manchester_decoding = manchester_decoding
              self.prepend_manchester = prepend_manchester
              self.sink_file = None
              if(sink_file != None):
                  self.sink_file = open(sink_file, "a")

              # amount of samples per symbol
              self.threshold = sample_rate / symbol_rate
              # amount of samples that can be wrong when counting the 1's and 0's
              self.error_threshold = self.threshold / 4
              self.packet = ''
              self.count_1 = 0 # Counts consecutive 1's
              self.count_0 = 0 # Counts consecutive 0's
              self.sample_1_complete = False
              self.sample_0_complete = False
              self.port_name = 'output_bits'
              self.message_port_register_out(pmt.intern(self.port_name))


          def work (self, input_items, output_items, *args, **kwargs): #new
              samples = input_items[0]
      	
              signal_detected = np.where(samples == 1)[0]
              if(len(signal_detected) > 0):
                  for i in range(0, len(samples) - 1):
                      self.count_samples(samples[i], samples[i + 1])
                      if(self.sample_1_complete):
                          self.count_1, self.sample_1_complete = self.process_sample('1', self.count_1)
                      elif(self.sample_0_complete):
                          self.count_0, self.sample_0_complete = self.process_sample('0', self.count_0)
              elif(len(samples) > 0 and len(self.packet) > 0):
                  self.packet_found()
      			#output_items = self.packet_found() # new

              return len(samples)
              #return len(output_items)

          def packet_found(self):
              self.packet += '0' # Last 0 of packet is never detected due to the bounded 0 count (in process_sample_0), so add manually

              if(self.manchester_decoding):
                  self.packet = self.manchester_decoder(self.packet)

              self.output_packet(self.packet)
              #output = self.output_packet(self.packet)

              self.packet = ''
              #return output #new
         
          def output_packet(self, output):
              if(self.sink_file):
                  self.sink_file.write(output + '\n')
              else:
                  #print(output)
                  p_string = pmt.to_pmt(output)
                  self.message_port_pub(pmt.intern(self.port_name), p_string)
                  #return output # new


          def count_samples(self, sample1, sample2):
              if(sample1 == 1):
                  self.count_1 += 1
                  if(sample2 == 0):
                      self.sample_1_complete = True 
              elif(sample1 == 0):
                  self.count_0 += 1
                  if(sample2 == 1):
                      self.sample_0_complete = True 

          
          def process_sample(self, bit, count):
              if(count > self.threshold - self.error_threshold and count < self.threshold + self.error_threshold):
                  self.packet += bit
              elif(count > (self.threshold - self.error_threshold) * 2 and count < (self.threshold + self.error_threshold) * 2):
                  self.packet += bit + bit
              return 0, False

      		
          def manchester_decoder(self, packet):
              if self.prepend_manchester:
                  packet='0'+packet # for the Honeywell 5816 a 0 must be prepended
              decode=''
              for i in range(0, len(packet) - 1, 2):
                  bits = packet[i] + packet[i + 1]
                  if(bits == '10'):
                      decode += '0'
                  elif(bits == '01'):
                      decode += '1'
                  else:
                      i -= 1
              return decode
    manchester_decoding: 'True'
    prepend_manchester: 'True'
    sample_rate: samp_rate
    sink_file: None
    symbol_rate: symbol_rate
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each this file is saved, GRC will instantiate the first class it finds to get
      ports and parameters of your block. The arguments to __init__  will be the
      parameters. All of them are required to have default values!

      This block was stolen from https://github.com/jordib123/ook-demodulator/blob/master/ook_demod_block.py

      Honeywell 5816 specific additions are mine.
      """
      import time
      import pmt
      import numpy as np
      from gnuradio import gr

      class blk (gr.sync_block):
          """
          Block to decode the data on an already squared signal, comprised of 0's and 1's.
          """
          def __init__ (self 
              , symbol_rate = 600
      		, sample_rate = 1e6
      		, manchester_decoding = False
      		, prepend_manchester = False
              , sink_file = None):
              """
              Constructor.

              Args:
                  symbol_rate -> Rate of symbols
                  sample_rate -> Number of samples per second
                  manchester_decoding -> Enable/disable manchester decoding
                  sink_file -> File to dump the packets. If it's 'None', prints them on STDOUT
              """
              gr.sync_block.__init__(
                  self,
                  name = 'OOK demod',
                  in_sig = [np.float32],
                  out_sig = []
              )
              self.manchester_decoding = manchester_decoding
              self.prepend_manchester = prepend_manchester
              self.sink_file = None
              if(sink_file != None):
                  self.sink_file = open(sink_file, "a")

              # amount of samples per symbol
              self.threshold = sample_rate / symbol_rate
              # amount of samples that can be wrong when counting the 1's and 0's
              self.error_threshold = self.threshold / 4
              self.packet = ''
              self.count_1 = 0 # Counts consecutive 1's
              self.count_0 = 0 # Counts consecutive 0's
              self.sample_1_complete = False
              self.sample_0_complete = False
              self.port_name = 'output_bits'
              self.message_port_register_out(pmt.intern(self.port_name))


          def work (self, input_items, output_items, *args, **kwargs): #new
              samples = input_items[0]
      	
              signal_detected = np.where(samples == 1)[0]
              if(len(signal_detected) > 0):
                  for i in range(0, len(samples) - 1):
                      self.count_samples(samples[i], samples[i + 1])
                      if(self.sample_1_complete):
                          self.count_1, self.sample_1_complete = self.process_sample('1', self.count_1)
                      elif(self.sample_0_complete):
                          self.count_0, self.sample_0_complete = self.process_sample('0', self.count_0)
              elif(len(samples) > 0 and len(self.packet) > 0):
                  self.packet_found()
      			#output_items = self.packet_found() # new

              return len(samples)
              #return len(output_items)

          def packet_found(self):
              self.packet += '0' # Last 0 of packet is never detected due to the bounded 0 count (in process_sample_0), so add manually

              if(self.manchester_decoding):
                  self.packet = self.manchester_decoder(self.packet)

              self.output_packet(self.packet)
              #output = self.output_packet(self.packet)

              self.packet = ''
              #return output #new
         
          def output_packet(self, output):
              if(self.sink_file):
                  self.sink_file.write(output + '\n')
              else:
                  #print(output)
                  p_string = pmt.to_pmt(output)
                  self.message_port_pub(pmt.intern(self.port_name), p_string)
                  #return output # new


          def count_samples(self, sample1, sample2):
              if(sample1 == 1):
                  self.count_1 += 1
                  if(sample2 == 0):
                      self.sample_1_complete = True 
              elif(sample1 == 0):
                  self.count_0 += 1
                  if(sample2 == 1):
                      self.sample_0_complete = True 

          
          def process_sample(self, bit, count):
              if(count > self.threshold - self.error_threshold and count < self.threshold + self.error_threshold):
                  self.packet += bit
              elif(count > (self.threshold - self.error_threshold) * 2 and count < (self.threshold + self.error_threshold) * 2):
                  self.packet += bit + bit
              return 0, False

      		
          def manchester_decoder(self, packet):
              if self.prepend_manchester:
                  packet='0'+packet # for the Honeywell 5816 a 0 must be prepended
              decode=''
              for i in range(0, len(packet) - 1, 2):
                  bits = packet[i] + packet[i + 1]
                  if(bits == '10'):
                      decode += '0'
                  elif(bits == '01'):
                      decode += '1'
                  else:
                      i -= 1
              return decode
    manchester_decoding: 'True'
    prepend_manchester: 'True'
    sample_rate: samp_rate//2
    sink_file: None
    symbol_rate: symbol_rate
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-offset'
    decim: '2'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, cutoff, cutoff/2, window.WIN_BLACKMAN, 6.76)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: cf
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: cf-offset
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    size: '102400'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5678
    timeout: '100'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_1, '0']
- [blocks_threshold_ff_0, '0', epy_block_1_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [epy_block_1, output_bits, blocks_message_debug_1, log]
- [epy_block_1, output_bits, zeromq_pub_msg_sink_0, in]
- [epy_block_1_0, output_bits, blocks_message_debug_1, log]
- [epy_block_1_0, output_bits, zeromq_pub_msg_sink_0, in]
- [freq_xlating_fft_filter_ccc_0, '0', blocks_throttle2_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
